# Keil uVision project arm-ac5.uvproj, settings and files
target ARM_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ARM_Debug
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: .\Source;.\Library;.\Startup
  asm include: .\Source
  memory RVCT4: ROM 0x08000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\ARM_Debug.sct
  link misc: --keep=*(.isr_vector)
  group Source
    ./Source/: main.c stm32f10x_it.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group Library
    ./Library/: STM32F10x_StdPeriph_Driver.lib
