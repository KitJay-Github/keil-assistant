# Keil uVision project c51.uvproj, settings and files
target C51_Debug (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG
  c include: .\Source;.\INC
  asm include: .\Startup
  group Source
    ./Source/: main.c delay.c
  group Startup
    ./Startup/: STARTUP.A51
  group Library
    ./Library/: lib-code.LIB
  group Documentation
    ./: readme.txt
target C51_Release (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: C51 +hex
  c flags: Optimize=9 SizeSpeed=1
  c misc: COMPACT
  c include: .\Source;.\INC
  asm include: .\Startup
