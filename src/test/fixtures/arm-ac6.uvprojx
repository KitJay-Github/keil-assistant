# Keil uVision project arm-ac6.uvprojx, settings and files
target Demo_Debug (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: DEBUG,USE_HAL_DRIVER,STM32F407xx
  c undefine: NDEBUG
  c include: .\Application;.\Drivers;.\Drivers\CMSIS
  asm include: .\Application
  memory RVCT4: ROM 0x08000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\Demo.sct
  group Application
    ./Application/: main.c app.c app.h
  group Drivers
    ./Drivers/: stm32f4xx_hal.c system_stm32f4xx.c
  group Documentation
    ./: readme.txt
  group Library
    ./Library/: libdemo.lib
target Demo_Release (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: Demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\Application;.\Drivers;.\Drivers\CMSIS
  asm include: .\Application
  memory RVCT4: ROM 0x08000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\Demo.sct
