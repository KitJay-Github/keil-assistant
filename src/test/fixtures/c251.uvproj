# Keil uVision project c251.uvproj, settings and files
target C251_Debug (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: C251 +hex
  asm include: .\Startup
  group Source
    ./Source/: main.c timer.c
  group Startup
    ./Startup/: STARTUP.A51
  group Library
    ./Library/: driver.LIB
target C251_Release (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: C251 +hex
  asm include: .\Startup
